## boards/shields/sofle_right/Kconfig.defconfig
```kconfig
if SHIELD_SOFLE_RIGHT

config ZMK_KEYBOARD_NAME
    default "Sofle Right"

endif
```
